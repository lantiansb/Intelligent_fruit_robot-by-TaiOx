# Keil uVision project Templete.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: HT32F52352 Holtek
  pack: Holtek.HT32_DFP.1.0.44
  cpu: IROM(0x00000000,0x1FE00) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf --bin -o #L.bin #L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52352_SK, USE_HT32F52342_52, USE_MEM_HT32F52352
  c include: ..\Libraries\CMSIS\Include;..\Libraries\Device\Holtek\HT32F5xxxx\Include;..\Libraries\HT32F5xxxx_Driver\inc;..\Libraries\HT32_USBD_Library\inc;..\Utilities;..\Libraries;..\Utilities\common\delay;..\Utilities\common;..\Utilities\common\sys;..\Utilities\common\usart;..\Hardware\GPIOInput;..\Hardware\OLED;..\Libraries\USER_LIB\PWM;..\Hardware\Servo;..\Libraries\HT32F5xxxx_Driver\inc;..\NET\CJSON;..\NET\device;..\NET\MQTT;..\NET\onenet;..\Hardware\K210;..\Hardware\LED;..\Hardware\Infrared_Tracking;..\APP
  asm define: USE_HT32_CHIP=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fe00
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry Reset_Handler
  group USER
    ../User/: main.c ht32f5xxxx_01_it.c
  group CONFIG
    ../Libraries/: ht32f5xxxx_conf.h ht32f5xxxx_01_usbdconf.h HT32F5xxxx_01_DebugSupport.ini
    ../Listing/: ht32_op.s
  group CMSIS
    ../Libraries/: system_ht32f5xxxx_01.c
  group MDK-ARM
    ../Listing/: startup_ht32f5xxxx_01.s
  group USBD_LIBRARY
    ../Libraries/HT32_USBD_Library/src/: ht32_usbd_core.c
  group LIBRARY
    ../Libraries/HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32_retarget.c ht32_serial.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_cmp.c ht32f5xxxx_crc.c ht32f5xxxx_ebi.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_i2s.c ht32f5xxxx_mctm.c ht32f5xxxx_pdma.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_sci.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_usbd.c ht32f5xxxx_wdt.c
    ../Libraries/USER_LIB/PWM/: pwm.c
  group UTILITES
    ../Utilities/: ht32_board.c
    ../Utilities/common/: i2c_eeprom.c spi_flash.c ebi_lcd.c
    ../Utilities/common/delay/: delay.c
    ../Utilities/common/sys/: sys.c
    ../Utilities/common/usart/: usart.c
  group Hardware
    ../Hardware/Servo/: servo.c
    ../Hardware/K210/: K210.c
    ../Hardware/LED/: led.c
    ../Hardware/OLED/: oled.c
    ../Hardware/Infrared_Tracking/: Track.c
  group NET
    ../NET/CJSON/: cJSON.c
    ../NET/MQTT/: MqttKit.c
    ../NET/device/: esp8266.c
    ../NET/onenet/: onenet.c
